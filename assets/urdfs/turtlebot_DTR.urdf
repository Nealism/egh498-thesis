Commit message: OBJECTIVE 1 HOMOGENEOUS DONE WITH BENCHMARK

File: assets/urdfs/turtlebot_DTR.urdf (robot description, URDF)
Before this commit: robot turtlebot, 33 links, 32 joints
Links:
- link base_link: geometry collision box size=0.8 0.51 0.4; collision cylinder length=0.10938 radius=0.176
